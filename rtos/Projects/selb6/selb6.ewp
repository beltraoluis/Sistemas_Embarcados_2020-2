# IAR project selb6.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C1294NCPDT
  ICCARM.CCIncludePath2: ..\drivers; ..\..\TivaWare_C_Series-2.1.4.178; ..\..\CMSIS-5.6.0\CMSIS\Core\Include; ..\..\CMSIS-5.6.0\CMSIS\RTOS2\Include; ..\..\CMSIS-5.6.0\CMSIS\RTOS2\RTX\Include; ..\..\TivaWare_C_Series-2.1.4.178\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: selb6.srec
  ILINK.IlinkOutputFile: selb5.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../drivers/: driverbuttons.c driverleds.c
    ../../TivaWare_C_Series-2.1.4.178/driverlib/ewarm/Exe/: driverlib.a
    ../../CMSIS-5.6.0/CMSIS/RTOS2/RTX/Library/IAR/IDE/CM4F/Exe/: RTX_CM.a
    src/: RTX_Config.c rtx_lib.c selb6.c startup_TM4C1294.s system_TM4C1294_TW.c
